# IAR project seusmartcar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: MK60D10
  ICCARM.CCIncludePath2: C:\Users\jluser\Desktop\seusmartcar\Libraries\Core; Libraries\Device; Libraries\Driver\inc; Libraries\camera\inc; User
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: seusmartcar.s19
  ILINK.IlinkOutputFile: seusmartcar.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group camera
    User/: DEV_SCCB.c
  group Device
    Libraries/Device/IAR-ARM/: startup_MK60D10.s
    Libraries/Device/: system_MK60D10.c
  group Driver
    Libraries/Driver/src/: adc.c can.c cmp.c common.c cpuidy.c crc.c dac.c dma.c enet.c flash.c flexbus.c ftm.c gpio.c i2c.c i2s.c lptmr.c nfc.c pdb.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
  group user
    User/: img_processing.c isr.c main.c oled.c varieble.c
    Libraries/camera/src/: init.c
